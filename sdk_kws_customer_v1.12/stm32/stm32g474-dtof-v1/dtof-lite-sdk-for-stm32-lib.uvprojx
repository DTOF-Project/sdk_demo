# Keil uVision project dtof-lite-sdk-for-stm32-lib.uvprojx, settings and files
target DTOF_GNSS (6160000::V6.16::ARMCLANG)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dtof_lib/dtof_lib +hex (library)
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: USE_HAL_DRIVER,STM32G474xx,STM32G4,DTOF_GNSS
  c misc: -Wno-gnu-zero-variadic-macro-arguments -Wno-covered-switch-default -Wno-address-of-packed-member -Wno-missing-noreturn -Wno-unused-function -Wno-newline-eof -Wno-empty-translation-unit -Wno-undef
  c include: .\board;..\3rdparty\STM32G4xx_HAL_Driver\Inc;..\3rdparty\CMSIS\Device\ST\STM32G4xx\Include;..\3rdparty;..\3rdparty\CMSIS\Include;..\..\..\app\nvram;..\..\..\sdk;..\fatfs;..\..\stm32;..\..\..\sdk_kws_customer_v1.11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group dtof_lib
    ../../lib/: dtof_cal_binoffset.c dtof_confidence.c dtof_hal.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0
