# Keil uVision project dtof-lite-sdk-for-stm32.uvprojx, settings and files
target DTOF_GNSS (6160000::V6.16::ARMCLANG)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_one_dtof_gnss +hex
  BeforeMake: ..\..\build_scripts\gen_hash_bash.bat
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: USE_HAL_DRIVER,STM32G474xx,STM32G4,DTOF_GNSS
  c misc: -Wno-gnu-zero-variadic-macro-arguments -Wno-covered-switch-default -Wno-address-of-packed-member -Wno-missing-noreturn -Wno-unused-function -Wno-newline-eof -Wno-empty-translation-unit -Wno-undef
  c include: .\board;..\3rdparty\STM32G4xx_HAL_Driver\Inc;..\3rdparty\CMSIS\Device\ST\STM32G4xx\Include;..\3rdparty;..\3rdparty\CMSIS\Include;..\..\..\app\nvram;..\..\sdk;..\fatfs;..\..\stm32;..\..\..\soc;..\..\application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../3rdparty/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
    ../3rdparty/CMSIS/Device/ST/STM32G4xx/Source/Templates/arm/: startup_stm32g474xx.s
    ../3rdparty/: stm32g4xx_it.c
  group target
    ./: main.c
    ./board/: board.c diskio.c
    ../fatfs/: ff.c ccsbcs.c
    ../: stm32_gpio.c stm32_i2c.c stm32_platform.c stm32_spi.c stm32_uart.c
  group stm32g4xx_hal_driver
    ../3rdparty/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c
  group dtof_sdk
    ../../sdk/src/: dtof_api.c dtof_driver.c dtof_endian.c dtof_fix16_float.c dtof_global_config.c dtof_calibration_ft.c
    ../../sdk/src/lib/: dtof_ft.lib
  group user
    ../user/device/: device.c ds_dev.c
    ../customer/: dtof_customer.c
    ../dev/: dtof_hal.c
  group app
    ../../application/: app_cmd.c
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDERR 1.2.0
