# IAR project dtof_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCIncludePath2: D:\customer_sdk\sdk_kws_customer_v1.12
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: kws_lib.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 39
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../sdk_kws_customer/sdk/lib/: dtof_cal_binoffset.c dtof_cal_cg.c dtof_cal_ft.c dtof_confidence.c dtof_hal.c
