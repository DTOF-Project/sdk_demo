# Keil uVision project dtof_lib.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dtof_lib (library)
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\sdk_kws_customer\sdk
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../../sdk_kws_customer/sdk/lib/: dtof_cal_binoffset.c dtof_cal_cg.c dtof_cal_ft.c dtof_confidence.c dtof_hal.c
