# Keil uVision project ft_lib.uvprojx, settings and files
target DTOF_GNSS (6160000::V6.16::ARMCLANG)
  device: STM32G474CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dtof_ft +hex (library)
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: USE_HAL_DRIVER,STM32G474xx,STM32G4,DTOF_GNSS
  c misc: -Wno-gnu-zero-variadic-macro-arguments -Wno-covered-switch-default -Wno-address-of-packed-member -Wno-missing-noreturn -Wno-unused-function -Wno-newline-eof -Wno-empty-translation-unit -Wno-undef
  c include: ..\..\soc\sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group lib
    ../../soc/sdk/src/: dtof_calibration_ft.c
    ../../soc/sdk/src/calibration/: dtof_bin_width_calibrate.c dtof_calibration_cg.c dtof_calibration_common.c dtof_calibration_reference_spad.c dtof_refbinoffset.c
    ../../soc/sdk/src/dev/: dtof_dev_api.c
software components: CMSIS:CORE 5.0.1, Compiler:I/O:STDERR 1.2.0
